File: vco1_pots.sch (EAGLE design)
At the start: 27 parts

Commit message: Rename one of the R3s to R37
Parts:
- renumbered R3 to R37
